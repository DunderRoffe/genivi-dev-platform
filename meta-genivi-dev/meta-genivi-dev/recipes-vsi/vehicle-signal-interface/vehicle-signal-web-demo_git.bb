#
# Copyright (C) 2017 GENIVI
# SPDX-License-Identifier: MIT
#


SUMMARY = "VSI web demo"
DESCRIPTION = "Simple demo of VSI using a web frontend"
AUTHOR = "Viktor Sjölind <viktor.sjolind@pelagicore.com>"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=815ca599c9df247a0c7f619bab123dad"
DEPENDS = "${PYTHON_PN}-crossbar"

SRCREV = "7e9b9e1a33efd1aa6ef05949af568781d1dee7b2"
SRC_URI = "git://github.com/genivi/vsi_web_demo.git"
